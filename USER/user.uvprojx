# Keil uVision project user.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: user +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\src;..\STM32F10x_FWLib\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\SYSTEM;..\HARDWARE;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\STMFLASH;..\RTT;..\HARDWARE\PRINTF
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c fputc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart_485.c usart_232.c
  group HARDWARE
    ../HARDWARE/: bsp.c ctrl.c pwrchk.c handle.c pid_control.c longkey.c wdg.c modbus.c lcdtest.c speedplan.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_wwdg.c stm32f10x_iwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group Readme
    ../Readme/: stm32说明.txt ucos说明.txt RCC配置.txt ucos启动流程.txt printf调试.txt PID算法.txt 卡尔曼滤波.txt 仿真.txt GPIO模式.txt
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group PRINTF
    ../HARDWARE/PRINTF/: doublebuf.c ringbuf.c usart1.c
